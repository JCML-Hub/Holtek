# Keil uVision project Holtek.uvprojx, settings and files
target Holtek Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.54
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1FE00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Holtek +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c include: ..\Libraries\CMSIS\Include;..\Libraries\Device\Holtek\HT32F5xxxx\Include;..\Libraries\HT32F5xxxx_Driver\inc;..\Libraries\HT32_USBD_Library\inc;..\RT-Thread\libcpu\arm\cortex-m0;..\RT-Thread\bsp\_template;..\RT-Thread\src;..\RT-Thread\include;..\Utilities;..\Libraries;.\Listings;..\Hardware\Delay;..\Hardware\LED;..\Hardware\UART
  asm define: USE_HT32_CHIP=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group MDK-ARM
    ./Listings/: startup_ht32f5xxxx_01.s
  group USER
    ../User/: main.c ht32f5xxxx_01_it.c
  group HARDWARE
    ../Hardware/Delay/: delay.c
    ../Hardware/LED/: led.c
    ../Hardware/UART/: uart.c
  group LIBRARY
    ../Libraries/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32_retarget.c ht32_serial.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group UTILITES
    ../Libraries/: system_ht32f5xxxx_01.c
    ../Utilities/: ht32_board.c
  group RT-THREAD
    ../RT-Thread/libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
    ../RT-Thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
    ../RT-Thread/bsp/_template/: board.c rtconfig.h
